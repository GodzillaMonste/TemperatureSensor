# Keil uVision project temperaturesensor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temperaturesensor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c AT24C02.c AT24C02.h Delay.c Delay.h DS18B20.c DS18B20.h I2C.c I2C.h Key.c Key.h LCD1602.c LCD1602.h OneWire.c OneWire.h Timer0.c Timer0.h MatrixKey.c MatrixKey.h Buzzer.c Buzzer.h DS1302.c DS1302.h
